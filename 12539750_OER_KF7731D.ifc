Properties of the parts of a building model (IFC2X3)

# File
Description: ViewDefinition [COBie2.4DesignDeliverable]
File name: 0001
Time: 2024-03-18T12:10:25
Written by: The EXPRESS Data Manager Version 5.02.0100.07 : 28 Aug 2013
Made in: 21.1.21.45 - Exporter 21.1.21.45 - Default UI
Comment: STEP Physical File produced by: The EXPRESS Data Manager Version 5.02.0100.07 : 28 Aug 2013 * Module: EDMstepFileFactory/EDMstandAlone * Creation date: Mon Mar 18 12:10:25 2024 * Host: DEGTL11901 * Database: C:\Users\deschvi\AppData\Local\Temp\b6bba7fa-7fcb-484c-9b34-367f6d71bf71\434dd802-f9b5-4ef1-ad27-320aa47a13ee\ifc * Database version: 5507 * Database creation date: Mon Mar 18 12:10:22 2024 * Schema: IFC2X3 * Model: DataRepository.ifc * Model creation date: Mon Mar 18 12:10:22 2024 * Header model: DataRepository.ifc_HeaderModel * Header model creation date: Mon Mar 18 12:10:22 2024 * EDMuser: sdai-user * EDMgroup: sdai-group * License ID and type: 5605 : Permanent license. Expiry date: * EDMstepFileFactory options: 020000

# IfcProject, 0001
LongName: Project Name; Phase: Project Status

# IfcSite, Default
RefLatitude: 42, 21, 31, 181945; RefLongitude: -71, -3, -24, -263305; RefElevation: 0 mm
Pset_ProductRequirements - Category: Project Information

# IfcBuildingElementProxy: 12539750_OER_KF7731D:38773105_OER_12539750_KF7731D, (2)
In: Default
Type - Material: z_Miele_Design_Steel_Chrom
Type - Pset_BuildingElementProxyCommon - Reference: 38773105_OER_12539750_KF7731D
Type - Pset_ManufacturerTypeInformation - Manufacturer: Miele
Type - Pset_QuantityTakeOff - Reference: 38773105_OER_12539750_KF7731D
Type - Pset_ProvisionForVoid - Width: 559 mm; Height: 1770 mm; Depth: 546 mm
Material: z_Miele_Design_Steel_Chrom, z_Miele_Design_Zinc_Steel, z_Miele_Design_BRWS, z_Miele_Design_Glass Black, z_Miele_Connection_Electric, z_Miele_Design_Glass
Pset_BuildingElementProxyCommon - sets with these values: 2
Pset_ProductRequirements - Category: Specialty Equipment

# IfcDistributionPort, Port_353816
Description: Flow; FlowDirection: SOURCEANDSINK
